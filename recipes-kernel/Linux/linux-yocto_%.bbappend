FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://disable-kaslr.cfg"
