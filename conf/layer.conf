## conf/layer.conf
```bitbake
# Define the layer name
LAYERNAME = "meta-disable-kaslr"

# Specify layer dependencies (e.g., core)
LAYERDEPENDS_meta-disable-kaslr = "core"
```
